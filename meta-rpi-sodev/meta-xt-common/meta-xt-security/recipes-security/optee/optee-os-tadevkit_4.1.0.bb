# Need to set PV manually or Bitbake tries to extract it
# from "optee-os-tadevkit.inc" filename
PV = "4.1.0"

require optee-os-tadevkit.inc

require recipes-security/optee/optee-os.inc

SRCREV = "12d7c4ee4642d2d761e39fbcf21a06fb77141dea"

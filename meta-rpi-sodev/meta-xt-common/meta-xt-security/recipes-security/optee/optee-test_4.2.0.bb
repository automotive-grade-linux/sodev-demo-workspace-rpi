require recipes-security/optee/optee-test.inc

SRCREV = "526d5bac1b65f907f67c05cd07beca72fbab88dd"

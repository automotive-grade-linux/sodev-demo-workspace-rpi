require rpi5-image-minimal-domd.bb

require optee-machine.inc

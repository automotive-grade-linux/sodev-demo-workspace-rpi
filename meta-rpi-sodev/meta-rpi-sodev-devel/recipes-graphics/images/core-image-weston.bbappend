# SPDX-License-Identifier: Apache-2.0
require recipes-core/images/xen-pkggroup-install.inc

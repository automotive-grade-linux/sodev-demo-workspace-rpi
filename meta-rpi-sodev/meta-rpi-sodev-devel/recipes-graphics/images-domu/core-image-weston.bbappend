# SPDX-License-Identifier: Apache-2.0
require recipes-core/images-domu/domu-common-install.inc

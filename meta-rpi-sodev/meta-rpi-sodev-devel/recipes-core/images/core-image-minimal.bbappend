# SPDX-License-Identifier: Apache-2.0
require xen-pkggroup-install.inc

# SPDX-License-Identifier: Apache-2.0
require domu-common-install.inc
